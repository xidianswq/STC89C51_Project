# Keil uVision project 简易密码识别.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM(0-0xFF) CLOCK(33000000) MODAT2
  output: 简易密码识别 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: easy_passworld_recongnise.c
