# Keil uVision project water_level_control.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: water_level_control +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\water_level_control;.\Hardware;.\System;.\User
  group Source Group 1
    ./: STARTUP.A51
  group Hardware
    ./Hardware/: motor.c motor.h lcd1602.c lcd1602.h
  group System
    ./System/: timer.c timer.h water_level_control.c water_level_control.h
  group User
    ./User/: main.c menu.c menu.h
